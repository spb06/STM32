# Keil uVision project external_interrupt.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c Sys_Clock_Config.c GPIO_Config.c Sys_Clock_Config.h GPIO_Config.h Delay.h Delay.c uart.h uart.c i2c.c i2c.h ADC.c ADC.h EXT_interrupt.c EXT_interrupt.h SPI.c SPI.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
